# Keil uVision project CSNKZLY.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: FT32F030G8BUx FMD
  pack: FMD.FT32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FT32F030x8
  c include: .\Source\FreeRTOS\include;.\Source\Tasks\inc;.\Source\Tk_Lib;.\Source\User\inc;..\Devices
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./Source/User/src/: ft32f0xx_it.c main.c
  group Tasks
    ./Source/Tasks/src/: TaskManager.c
  group FreeRTOS
    ./Source/FreeRTOS/: list.c queue.c tasks.c timers.c
    ./Source/FreeRTOS/portable/: heap_4.c port.c
  group Devices
    ../Devices/: App.c dev_ad9877.c dev_adc.c dev_exit.c dev_flash.c dev_gpio.c dev_pid.c dev_pwm.c
software components: CMSIS:CORE 5.2.0, Device:FT32Driver:ADC 1.0.1, Device:FT32Driver:COMMON 1.0.1, Device:FT32Driver:CRC 1.0.1, Device:FT32Driver:CRS 1.0.1, Device:FT32Driver:DAC 1.0.1, Device:FT32Driver:DEBUG 1.0.1, Device:FT32Driver:DMA 1.0.1, Device:FT32Driver:EXTI 1.0.1, Device:FT32Driver:FLASH 1.0.1, Device:FT32Driver:GPIO 1.0.1, Device:FT32Driver:I2C 1.0.1, Device:FT32Driver:IWDG 1.0.1, Device:FT32Driver:MISC 1.0.1, Device:FT32Driver:PWR 1.0.1, Device:FT32Driver:RCC 1.0.1, Device:FT32Driver:RTC 1.0.1, Device:FT32Driver:SPI 1.0.1, Device:FT32Driver:SYSCFG 1.0.1, Device:FT32Driver:TIM 1.0.1, Device:FT32Driver:USART 1.0.1, Device:FT32Driver:WWDG 1.0.1, Device:Startup 1.0.1
