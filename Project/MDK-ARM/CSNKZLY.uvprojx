# Keil uVision project CSNKZLY.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: FT32F030G8BUx FMD
  pack: FMD.FT32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CSNKZLY +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User\Include;..\..\Devices;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../USER/Sourse/: ft32f0xx_it.c main.c bsp_systick.c
  group Devices
    ../../Devices/: App.c App.h dev_ad9877.c dev_ad9877.h dev_adc.c dev_adc.h dev_exit.c dev_exit.h dev_flash.c dev_flash.h dev_gpio.c dev_gpio.h dev_pid.c dev_pid.h dev_pwm.c dev_pwm.h
software components: CMSIS:CORE 5.2.0, Device:FT32Driver:ADC 1.0.1, Device:FT32Driver:COMMON 1.0.1, Device:FT32Driver:CRC 1.0.1, Device:FT32Driver:CRS 1.0.1, Device:FT32Driver:DAC 1.0.1, Device:FT32Driver:DEBUG 1.0.1, Device:FT32Driver:DMA 1.0.1, Device:FT32Driver:EXTI 1.0.1, Device:FT32Driver:FLASH 1.0.1, Device:FT32Driver:GPIO 1.0.1, Device:FT32Driver:I2C 1.0.1, Device:FT32Driver:IWDG 1.0.1, Device:FT32Driver:MISC 1.0.1, Device:FT32Driver:PWR 1.0.1, Device:FT32Driver:RCC 1.0.1, Device:FT32Driver:RTC 1.0.1, Device:FT32Driver:SPI 1.0.1, Device:FT32Driver:SYSCFG 1.0.1, Device:FT32Driver:TIM 1.0.1, Device:FT32Driver:USART 1.0.1, Device:FT32Driver:WWDG 1.0.1, Device:Startup 1.0.1
